# Keil uVision project rfid.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rfid
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Src;.\Inc;..\..\..\STM32_SPI_SDCARD-master\STM32_SPI_SDCARD-master - Copy\STM32F4_HAL_SPI_SDCARD\Src;..\..\..\STM32_SPI_SDCARD-master\STM32_SPI_SDCARD-master - Copy\STM32F4_HAL_SPI_SDCARD\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    ./Src/: RFID.c SPI.c delay.c
  group fatfs
    ../../../STM32_SPI_SDCARD-master/STM32_SPI_SDCARD-master - Copy/STM32F4_HAL_SPI_SDCARD/Src/: fatfs.c fatfs_sd.c stm32f4xx_hal_msp.c stm32f4xx_it.c syscalls.c system_stm32f4xx.c user_diskio.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
